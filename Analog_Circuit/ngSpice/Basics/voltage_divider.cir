* Simple voltage divider circuit
V1 in 0 DC 10
R1 in out 1k
R2 out 0 1k

* DC analysis
.dc V1 0 10 1

* .control block for automation
.control
run
plot v(out)
.endc
